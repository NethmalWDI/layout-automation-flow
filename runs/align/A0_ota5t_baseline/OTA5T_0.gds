* Circuit, read from the shapes
.subckt OTA5T_0 INN INP OUTP VBIAS VDD VSS
XM1 n1 VBIAS VSS VSS sky130_fd_pr__nfet_01v8 w=0.63 l=0.15 m=38
XM2 OUTP INN n1 VSS sky130_fd_pr__nfet_01v8 w=0.63 l=0.15 m=38
XM3 n2 INP n1 VSS sky130_fd_pr__nfet_01v8 w=0.63 l=0.15 m=38
XM4 n2 n2 VDD VDD sky130_fd_pr__pfet_01v8 w=2.1 l=0.15 m=4
XM5 OUTP n2 VDD VDD sky130_fd_pr__pfet_01v8 w=2.1 l=0.15 m=4
.ends

# Layout, gdstk code
from math import pi, radians
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
nwell = (64, 20)
diff = (65, 20)
tap = (65, 44)
poly = (66, 20)
licon = (66, 44)
li1 = (67, 20)
mcon = (67, 44)
met1 = (68, 20)
via = (68, 44)
met2 = (69, 20)
via2 = (69, 44)
met3 = (70, 20)
via3 = (70, 44)
met4 = (71, 20)
nsdm = (93, 44)
psdm = (94, 20)
L100_5 = (100, 5)
L104_0 = (104, 0)
L235_5 = (235, 5)

scm_pmos_42512307_x2_y1_ = lib.new_cell('SCM_PMOS_42512307_X2_Y1_1792775075')
R(scm_pmos_42512307_x2_y1_, nwell, [(0,0,5.16,7.56)])
R(scm_pmos_42512307_x2_y1_, diff, [(0.735,1.785,4.425,3.885)])
A(scm_pmos_42512307_x2_y1_, tap, 1.205, 6.16, 0.17, 1.12, 4, 1, 0.86, 0)
A(scm_pmos_42512307_x2_y1_, poly, 1, 1.26, 0.15, 3.36, 8, 1, 0.43, 0)
A(scm_pmos_42512307_x2_y1_, poly, 1, 4.485, 0.58, 0.27, 4, 1, 0.86, 0)
A(scm_pmos_42512307_x2_y1_, licon, 0.775, 1.865, 0.17, 0.17, 3, 5, 0.43, 0.34)
A(scm_pmos_42512307_x2_y1_, licon, 1.635, 1.865, 0.17, 0.17, 3, 5, 0.43, 0.34)
A(scm_pmos_42512307_x2_y1_, licon, 2.495, 1.865, 0.17, 0.17, 3, 5, 0.43, 0.34)
A(scm_pmos_42512307_x2_y1_, licon, 3.355, 1.865, 0.17, 0.17, 3, 5, 0.43, 0.34)
A(scm_pmos_42512307_x2_y1_, licon, 1.205, 4.535, 0.17, 0.17, 4, 2, 0.86, 2.1)
A(scm_pmos_42512307_x2_y1_, li1, 0.735, 0.335, 0.25, 3.53, 9, 1, 0.43, 0)
A(scm_pmos_42512307_x2_y1_, li1, 1.165, 4.115, 0.25, 1.01, 4, 2, 0.86, 2.1)
A(scm_pmos_42512307_x2_y1_, mcon, 0.775, 1.175, 0.17, 0.17, 5, 1, 0.86, 0)
A(scm_pmos_42512307_x2_y1_, mcon, 1.205, 4.535, 0.17, 0.17, 4, 2, 0.86, 2.1)
R(scm_pmos_42512307_x2_y1_, mcon, [(1.205,0.335,1.375,0.505), (3.785,0.335,3.955,0.505), (2.065,0.755,2.235,0.925), (2.925,0.755,3.095,0.925)])
R(scm_pmos_42512307_x2_y1_, met1, [(1.12,0.28,4.04,0.56), (1.98,0.7,3.18,0.98), (0.69,1.12,4.47,1.4), (1.12,4.48,4.04,4.76), (1.12,6.58,4.04,6.86)])
R(scm_pmos_42512307_x2_y1_, via, [(2.075,0.345,2.225,0.495), (2.935,1.185,3.085,1.335), (2.075,4.545,2.225,4.695), (2.935,6.645,3.085,6.795)])
R(scm_pmos_42512307_x2_y1_, met2, [(2.01,0.26,2.29,4.78), (2.87,1.1,3.15,6.88)])
R(scm_pmos_42512307_x2_y1_, nsdm, [(0,5.88,5.16,7.56)])
R(scm_pmos_42512307_x2_y1_, psdm, [(0,0,5.16,5.88)])
R(scm_pmos_42512307_x2_y1_, L100_5, [(0,0,5.16,7.56)])

dp_nmos_b_42587218_x19_y = lib.new_cell('DP_NMOS_B_42587218_X19_Y1_1792775073')
R(dp_nmos_b_42587218_x19_y, diff, [(0.735,2.52,33.665,3.15)])
A(dp_nmos_b_42587218_x19_y, tap, 1.205, 6.16, 0.17, 1.12, 38, 1, 0.86, 0)
A(dp_nmos_b_42587218_x19_y, poly, 1, 1.26, 0.15, 3.36, 76, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, poly, 1, 4.485, 0.58, 0.27, 38, 1, 0.86, 0)
A(dp_nmos_b_42587218_x19_y, licon, 0.775, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 1.635, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 2.495, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 3.355, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 4.215, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 5.075, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 5.935, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 6.795, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 7.655, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 8.515, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 9.375, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 10.235, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 11.095, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 11.955, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 12.815, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 13.675, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 14.535, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 15.395, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 16.255, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 17.115, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 17.975, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 18.835, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 19.695, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 20.555, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 21.415, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 22.275, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 23.135, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 23.995, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 24.855, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 25.715, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 26.575, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 27.435, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 28.295, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 29.155, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 30.015, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 30.875, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 31.735, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 32.595, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, licon, 1.205, 4.535, 0.17, 0.17, 38, 2, 0.86, 2.1)
A(dp_nmos_b_42587218_x19_y, li1, 0.735, 0.335, 0.25, 3.53, 77, 1, 0.43, 0)
A(dp_nmos_b_42587218_x19_y, li1, 1.165, 4.115, 0.25, 1.01, 38, 2, 0.86, 2.1)
A(dp_nmos_b_42587218_x19_y, mcon, 1.205, 0.335, 0.17, 0.17, 19, 2, 1.72, 4.2)
A(dp_nmos_b_42587218_x19_y, mcon, 2.065, 0.755, 0.17, 0.17, 19, 2, 1.72, 4.2)
A(dp_nmos_b_42587218_x19_y, mcon, 0.775, 1.175, 0.17, 0.17, 39, 1, 0.86, 0)
A(dp_nmos_b_42587218_x19_y, mcon, 1.205, 6.635, 0.17, 0.17, 38, 1, 0.86, 0)
R(dp_nmos_b_42587218_x19_y, met1, [(1.12,0.28,32.42,0.56), (1.98,0.7,33.28,0.98), (0.69,1.12,33.71,1.4), (1.12,4.48,32.42,4.76), (1.98,4.9,33.28,5.18), (1.12,6.58,33.28,6.86)])
R(dp_nmos_b_42587218_x19_y, nsdm, [(0,0,34.4,5.88)])
R(dp_nmos_b_42587218_x19_y, psdm, [(0,5.88,34.4,7.56)])
R(dp_nmos_b_42587218_x19_y, L100_5, [(0,0,34.4,7.56)])

nmos_s_83430483_x19_y1_1 = lib.new_cell('NMOS_S_83430483_X19_Y1_1792775074')
R(nmos_s_83430483_x19_y1_1, diff, [(0.735,2.52,17.325,3.15)])
A(nmos_s_83430483_x19_y1_1, tap, 1.205, 6.16, 0.17, 1.12, 19, 1, 0.86, 0)
A(nmos_s_83430483_x19_y1_1, poly, 1, 1.26, 0.15, 3.36, 38, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, poly, 1, 4.485, 0.58, 0.27, 19, 1, 0.86, 0)
A(nmos_s_83430483_x19_y1_1, licon, 0.775, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 1.635, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 2.495, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 3.355, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 4.215, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 5.075, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 5.935, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 6.795, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 7.655, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 8.515, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 9.375, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 10.235, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 11.095, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 11.955, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 12.815, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 13.675, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 14.535, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 15.395, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 16.255, 2.6, 0.17, 0.17, 3, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, licon, 1.205, 4.535, 0.17, 0.17, 19, 2, 0.86, 2.1)
A(nmos_s_83430483_x19_y1_1, li1, 0.735, 0.335, 0.25, 3.53, 39, 1, 0.43, 0)
A(nmos_s_83430483_x19_y1_1, li1, 1.165, 4.115, 0.25, 1.01, 19, 2, 0.86, 2.1)
A(nmos_s_83430483_x19_y1_1, mcon, 1.205, 0.335, 0.17, 0.17, 19, 2, 0.86, 4.2)
A(nmos_s_83430483_x19_y1_1, mcon, 0.775, 0.755, 0.17, 0.17, 20, 1, 0.86, 0)
A(nmos_s_83430483_x19_y1_1, mcon, 1.205, 6.635, 0.17, 0.17, 19, 1, 0.86, 0)
R(nmos_s_83430483_x19_y1_1, met1, [(1.12,0.28,16.94,0.56), (0.69,0.7,17.37,0.98), (1.12,4.48,16.94,4.76), (1.12,6.58,16.94,6.86)])
R(nmos_s_83430483_x19_y1_1, via, [(9.385,0.765,9.535,0.915), (9.385,6.645,9.535,6.795)])
R(nmos_s_83430483_x19_y1_1, met2, [(9.32,0.68,9.6,6.88)])
R(nmos_s_83430483_x19_y1_1, nsdm, [(0,0,18.06,5.88)])
R(nmos_s_83430483_x19_y1_1, psdm, [(0,5.88,18.06,7.56)])
R(nmos_s_83430483_x19_y1_1, L100_5, [(0,0,18.06,7.56)])

ota5t_0 = lib.new_cell('OTA5T_0')
R(ota5t_0, met1, [(10.16,0.7,10.48,0.98), (10.16,0.7,10.48,0.98), (10.16,0.7,10.48,0.98), (14.46,6.16,14.78,6.44), (14.46,6.16,14.78,6.44), (20.48,6.58,20.8,6.86), (20.48,6.58,20.8,6.86), (20.05,7,20.37,7.28), (20.05,7,20.37,7.28), (14.46,7.84,14.78,8.12), (14.46,7.84,14.78,8.12), (20.48,8.26,20.8,8.54), (20.48,8.26,20.8,8.54)])
P(ota5t_0, met1, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(ota5t_0, via, [(10.245,0.765,10.395,0.915), (10.245,0.765,10.395,0.915), (10.245,0.765,10.395,0.915), (14.545,6.225,14.695,6.375), (14.545,6.225,14.695,6.375), (20.565,6.645,20.715,6.795), (20.565,6.645,20.715,6.795), (20.135,7.065,20.285,7.215), (20.135,7.065,20.285,7.215), (14.545,7.905,14.695,8.055), (14.545,7.905,14.695,8.055), (20.565,8.325,20.715,8.475), (20.565,8.325,20.715,8.475)])
R(ota5t_0, met2, [(20.93,-0.185,21.21,0.185), (20.93,-0.185,21.21,0.185), (20.93,0,21.21,8.82), (10.18,0.68,10.46,1), (10.18,0.68,10.46,1), (10.18,0.68,10.46,1), (10.18,0.84,10.46,8.82), (14.48,6.14,14.76,6.46), (14.48,6.14,14.76,6.46), (14.48,6.3,14.76,7.98), (20.5,6.56,20.78,6.88), (20.5,6.56,20.78,6.88), (20.5,6.72,20.78,8.4), (20.07,6.98,20.35,7.3), (20.07,6.98,20.35,7.3), (20.07,7.14,20.35,7.98), (14.48,7.82,14.76,8.14), (14.48,7.82,14.76,8.14), (20.5,8.24,20.78,8.56), (20.5,8.24,20.78,8.56), (9.32,8.635,9.6,9.005), (9.32,8.635,9.6,9.005), (10.18,8.635,10.46,9.005), (10.18,8.635,10.46,9.005), (10.18,8.635,10.46,9.005)])
P(ota5t_0, met2, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(ota5t_0, via2, [(20.97,-0.1,21.17,0.1), (20.97,-0.1,21.17,0.1), (9.36,8.72,9.56,8.92), (9.36,8.72,9.56,8.92), (10.22,8.72,10.42,8.92), (10.22,8.72,10.42,8.92), (10.22,8.72,10.42,8.92)])
A(ota5t_0, met3, -0.4, -0.4, 4.24, 0.8, 3, 2, 3.44, 8.82)
A(ota5t_0, met3, 23.68, -0.4, 4.24, 0.8, 3, 2, 3.44, 8.82)
R(ota5t_0, met3, [(-0.165,-0.4,0.165,0.4), (9.92,-0.4,12.24,0.4), (11.44,-0.4,14.16,0.4), (13.36,-0.4,17.6,0.4), (16.8,-0.4,21.04,0.4), (20.24,-0.4,24.08,0.4), (20.905,-0.4,21.235,0.4), (20.905,-0.4,21.235,0.4), (23.28,-0.4,24.48,0.4), (23.515,-0.4,23.845,0.4), (34,-0.4,35.92,0.4), (35.12,-0.4,38.24,0.4), (9.295,8.42,9.625,9.22), (9.295,8.42,9.625,9.22), (9.92,8.42,12.24,9.22), (10.155,8.42,10.485,9.22), (10.155,8.42,10.485,9.22), (10.155,8.42,10.485,9.22), (11.44,8.42,14.16,9.22), (11.675,8.42,12.005,9.22), (13.36,8.42,17.6,9.22), (16.8,8.42,21.04,9.22), (20.24,8.42,24.08,9.22), (23.28,8.42,24.48,9.22), (34,8.42,35.92,9.22), (35.12,8.42,38.24,9.22), (35.355,8.42,35.685,9.22)])
R(ota5t_0, via3, [(-0.1,-0.1,0.1,0.1), (23.58,-0.1,23.78,0.1), (11.74,8.72,11.94,8.92), (35.42,8.72,35.62,8.92)])
A(ota5t_0, met4, -0.59, -0.59, 1.18, 10, 4, 1, 11.84, 0)
R(ota5t_0, met4, [(-0.59,-0.165,0.59,0.165), (23.09,-0.165,24.27,0.165), (11.25,8.655,12.43,8.985), (34.93,8.655,36.11,8.985)])
R(ota5t_0, L104_0, [(-4,-4,42.83,19.71)])
R(ota5t_0, L235_5, [(0,0,38.83,15.71)])
ota5t_0.add(gdstk.Reference(scm_pmos_42512307_x2_y1_, (18.06,7.56)))
ota5t_0.add(gdstk.Reference(dp_nmos_b_42587218_x19_y, (37.84,7.56), rotation=pi))
ota5t_0.add(gdstk.Reference(nmos_s_83430483_x19_y1_1, (0,7.56)))
ota5t_0.add(gdstk.Label('OUTP', (20.21,6.72), layer=68, texttype=5))
ota5t_0.add(gdstk.Label('INP', (21.07,2.94), layer=68, texttype=5))
ota5t_0.add(gdstk.Label('INN', (20.21,2.52), layer=68, texttype=5))
ota5t_0.add(gdstk.Label('VBIAS', (9.03,12.18), layer=68, texttype=5))
ota5t_0.add(gdstk.Label('VSS', (11.84,4.41), layer=71, texttype=5))
ota5t_0.add(gdstk.Label('VSS', (10.32,4.83), layer=69, texttype=5))
ota5t_0.add(gdstk.Label('VSS', (11.84,4.41), layer=71, texttype=5))
ota5t_0.add(gdstk.Label('VSS', (11.84,4.41), layer=71, texttype=5))
ota5t_0.add(gdstk.Label('VSS', (11.84,4.41), layer=71, texttype=5))
ota5t_0.add(gdstk.Label('VSS', (11.84,4.41), layer=71, texttype=5))
ota5t_0.add(gdstk.Label('VDD', (21.07,4.41), layer=69, texttype=5))
ota5t_0.add(gdstk.Label('VDD', (23.68,4.41), layer=71, texttype=5))
ota5t_0.add(gdstk.Label('VDD', (23.68,4.41), layer=71, texttype=5))

lib.write_gds('OTA5T_0.gds')
