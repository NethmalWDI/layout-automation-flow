* Circuit, read from the shapes
.subckt TELESCOPIC_OTA_0 0 VBIASN VBIASP1 VBIASP2 VDD VINN VINP VOUTN VOUTP
XM1 n1 n1 0 0 sky130_fd_pr__nfet_01v8_lvt w=0.84 l=0.15 m=2
XM2 VOUTN VBIASN n2 0 sky130_fd_pr__nfet_01v8_lvt w=0.84 l=0.15 m=2
XM3 n2 VINP n3 0 sky130_fd_pr__nfet_01v8_lvt w=0.84 l=0.15 m=4
XM4 n3 n1 0 0 sky130_fd_pr__nfet_01v8_lvt w=0.84 l=0.15 m=2
XM5 n4 VINN n3 0 sky130_fd_pr__nfet_01v8_lvt w=0.84 l=0.15 m=4
XM6 VOUTP VBIASN n4 0 sky130_fd_pr__nfet_01v8_lvt w=0.84 l=0.15 m=2
XM7 VOUTN VBIASP1 n5 VDD sky130_fd_pr__pfet_01v8_lvt w=0.84 l=0.15 m=2
XM8 n5 VBIASP2 VDD VDD sky130_fd_pr__pfet_01v8_lvt w=0.84 l=0.15 m=2
XM9 n6 VBIASP2 VDD VDD sky130_fd_pr__pfet_01v8_lvt w=0.84 l=0.15 m=2
XM10 VOUTP VBIASP1 n6 VDD sky130_fd_pr__pfet_01v8_lvt w=0.84 l=0.15 m=2
.ends

# Layout, gdstk code
from math import pi, radians
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
nwell = (64, 20)
diff = (65, 20)
tap = (65, 44)
poly = (66, 20)
licon = (66, 44)
li1 = (67, 20)
mcon = (67, 44)
met1 = (68, 20)
via = (68, 44)
met2 = (69, 20)
nsdm = (93, 44)
psdm = (94, 20)
L100_5 = (100, 5)
L104_0 = (104, 0)
lvtn = (125, 44)
L235_5 = (235, 5)

scm_nmos_462578_x1_y1_17 = lib.new_cell('SCM_NMOS_462578_X1_Y1_1792788341')
R(scm_nmos_462578_x1_y1_17, diff, [(0.735,2.415,2.705,3.255)])
R(scm_nmos_462578_x1_y1_17, tap, [(1.205,6.16,1.375,7.28), (2.065,6.16,2.235,7.28)])
A(scm_nmos_462578_x1_y1_17, poly, 1, 1.26, 0.15, 3.36, 4, 1, 0.43, 0)
R(scm_nmos_462578_x1_y1_17, poly, [(1,4.485,1.58,4.755), (1.86,4.485,2.44,4.755)])
A(scm_nmos_462578_x1_y1_17, licon, 0.775, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(scm_nmos_462578_x1_y1_17, licon, 1.635, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
R(scm_nmos_462578_x1_y1_17, licon, [(1.205,4.535,1.375,4.705), (2.065,4.535,2.235,4.705), (1.205,6.635,1.375,6.805), (2.065,6.635,2.235,6.805)])
A(scm_nmos_462578_x1_y1_17, li1, 0.735, 0.335, 0.25, 3.53, 5, 1, 0.43, 0)
R(scm_nmos_462578_x1_y1_17, li1, [(1.165,4.115,1.415,5.125), (2.025,4.115,2.275,5.125), (1.165,6.215,1.415,7.225), (2.025,6.215,2.275,7.225)])
A(scm_nmos_462578_x1_y1_17, mcon, 0.775, 1.175, 0.17, 0.17, 3, 1, 0.86, 0)
R(scm_nmos_462578_x1_y1_17, mcon, [(1.205,0.335,1.375,0.505), (2.065,0.755,2.235,0.925), (1.205,4.535,1.375,4.705), (2.065,4.535,2.235,4.705), (1.205,6.635,1.375,6.805), (2.065,6.635,2.235,6.805)])
R(scm_nmos_462578_x1_y1_17, met1, [(0.26,0.28,1.46,0.56), (1.12,0.7,2.32,0.98), (0.69,1.12,2.75,1.4), (1.12,4.48,2.32,4.76), (1.12,6.58,2.32,6.86)])
R(scm_nmos_462578_x1_y1_17, via, [(1.215,0.345,1.365,0.495), (2.075,1.185,2.225,1.335), (1.215,4.545,1.365,4.695), (2.075,6.645,2.225,6.795)])
R(scm_nmos_462578_x1_y1_17, met2, [(1.15,0.26,1.43,4.78), (2.01,1.1,2.29,6.88)])
R(scm_nmos_462578_x1_y1_17, nsdm, [(0,0,3.44,5.88)])
R(scm_nmos_462578_x1_y1_17, psdm, [(0,5.88,3.44,7.56)])
R(scm_nmos_462578_x1_y1_17, L100_5, [(0,0,3.44,7.56)])
R(scm_nmos_462578_x1_y1_17, lvtn, [(0.645,2.285,2.795,3.385)])

cmc_pmos_58951767_x1_y1_ = lib.new_cell('CMC_PMOS_58951767_X1_Y1_1792788337')
R(cmc_pmos_58951767_x1_y1_, nwell, [(0,0,3.44,7.56)])
R(cmc_pmos_58951767_x1_y1_, diff, [(0.735,2.415,2.705,3.255)])
R(cmc_pmos_58951767_x1_y1_, tap, [(1.205,6.16,1.375,7.28), (2.065,6.16,2.235,7.28)])
A(cmc_pmos_58951767_x1_y1_, poly, 1, 1.26, 0.15, 3.36, 4, 1, 0.43, 0)
R(cmc_pmos_58951767_x1_y1_, poly, [(1,4.485,1.58,4.755), (1.86,4.485,2.44,4.755)])
A(cmc_pmos_58951767_x1_y1_, licon, 0.775, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(cmc_pmos_58951767_x1_y1_, licon, 1.635, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
R(cmc_pmos_58951767_x1_y1_, licon, [(1.205,4.535,1.375,4.705), (2.065,4.535,2.235,4.705), (1.205,6.635,1.375,6.805), (2.065,6.635,2.235,6.805)])
A(cmc_pmos_58951767_x1_y1_, li1, 0.735, 0.335, 0.25, 3.53, 5, 1, 0.43, 0)
R(cmc_pmos_58951767_x1_y1_, li1, [(1.165,4.115,1.415,5.125), (2.025,4.115,2.275,5.125), (1.165,6.215,1.415,7.225), (2.025,6.215,2.275,7.225)])
A(cmc_pmos_58951767_x1_y1_, mcon, 0.775, 1.175, 0.17, 0.17, 3, 1, 0.86, 0)
R(cmc_pmos_58951767_x1_y1_, mcon, [(1.205,0.335,1.375,0.505), (2.065,0.755,2.235,0.925), (1.205,4.535,1.375,4.705), (2.065,4.535,2.235,4.705), (1.205,6.635,1.375,6.805), (2.065,6.635,2.235,6.805)])
R(cmc_pmos_58951767_x1_y1_, met1, [(0.26,0.28,1.46,0.56), (1.12,0.7,2.32,0.98), (0.69,1.12,2.75,1.4), (1.12,4.48,2.32,4.76), (1.12,6.58,2.75,6.86)])
R(cmc_pmos_58951767_x1_y1_, via, [(2.505,1.185,2.655,1.335), (2.505,6.645,2.655,6.795)])
R(cmc_pmos_58951767_x1_y1_, met2, [(2.44,1.1,2.72,6.88)])
R(cmc_pmos_58951767_x1_y1_, nsdm, [(0,5.88,3.44,7.56)])
R(cmc_pmos_58951767_x1_y1_, psdm, [(0,0,3.44,5.88)])
R(cmc_pmos_58951767_x1_y1_, L100_5, [(0,0,3.44,7.56)])
R(cmc_pmos_58951767_x1_y1_, lvtn, [(0.645,2.285,2.795,3.385)])

cmc_s_nmos_b_53754070_x1 = lib.new_cell('CMC_S_NMOS_B_53754070_X1_Y1_1792788338')
R(cmc_s_nmos_b_53754070_x1, diff, [(0.735,2.415,1.845,3.255), (4.175,2.415,5.285,3.255)])
R(cmc_s_nmos_b_53754070_x1, tap, [(1.205,6.16,1.375,7.28), (4.645,6.16,4.815,7.28)])
R(cmc_s_nmos_b_53754070_x1, poly, [(1,1.26,1.15,4.62), (1.43,1.26,1.58,4.62), (4.44,1.26,4.59,4.62), (4.87,1.26,5.02,4.62), (1,4.485,1.58,4.755), (4.44,4.485,5.02,4.755)])
A(cmc_s_nmos_b_53754070_x1, licon, 0.775, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(cmc_s_nmos_b_53754070_x1, licon, 4.215, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
R(cmc_s_nmos_b_53754070_x1, licon, [(1.205,4.535,1.375,4.705), (4.645,4.535,4.815,4.705), (1.205,6.635,1.375,6.805), (4.645,6.635,4.815,6.805)])
A(cmc_s_nmos_b_53754070_x1, li1, 0.735, 0.335, 0.25, 3.53, 3, 1, 0.43, 0)
A(cmc_s_nmos_b_53754070_x1, li1, 4.175, 0.335, 0.25, 3.53, 3, 1, 0.43, 0)
R(cmc_s_nmos_b_53754070_x1, li1, [(1.165,4.115,1.415,5.125), (4.605,4.115,4.855,5.125), (1.165,6.215,1.415,7.225), (4.605,6.215,4.855,7.225)])
R(cmc_s_nmos_b_53754070_x1, mcon, [(1.205,0.335,1.375,0.505), (4.645,0.755,4.815,0.925), (0.775,1.175,0.945,1.345), (1.635,1.175,1.805,1.345), (4.215,1.595,4.385,1.765), (5.075,1.595,5.245,1.765), (1.205,4.535,1.375,4.705), (4.645,4.535,4.815,4.705), (1.205,6.635,1.375,6.805), (4.645,6.635,4.815,6.805)])
R(cmc_s_nmos_b_53754070_x1, met1, [(1.12,0.28,2.32,0.56), (3.7,0.7,4.9,0.98), (0.69,1.12,1.89,1.4), (4.13,1.54,5.33,1.82), (1.12,4.48,4.9,4.76), (1.12,6.58,4.9,6.86)])
R(cmc_s_nmos_b_53754070_x1, nsdm, [(0,0,6.02,5.88)])
R(cmc_s_nmos_b_53754070_x1, psdm, [(0,5.88,6.02,7.56)])
R(cmc_s_nmos_b_53754070_x1, L100_5, [(0,0,6.02,7.56)])
R(cmc_s_nmos_b_53754070_x1, lvtn, [(1,2.285,1.58,3.385), (4.44,2.285,5.02,3.385)])

cmc_s_pmos_b_35717683_x1 = lib.new_cell('CMC_S_PMOS_B_35717683_X1_Y1_1792788339')
R(cmc_s_pmos_b_35717683_x1, nwell, [(0,0,6.02,7.56)])
R(cmc_s_pmos_b_35717683_x1, diff, [(0.735,2.415,1.845,3.255), (4.175,2.415,5.285,3.255)])
R(cmc_s_pmos_b_35717683_x1, tap, [(1.205,6.16,1.375,7.28), (4.645,6.16,4.815,7.28)])
R(cmc_s_pmos_b_35717683_x1, poly, [(1,1.26,1.15,4.62), (1.43,1.26,1.58,4.62), (4.44,1.26,4.59,4.62), (4.87,1.26,5.02,4.62), (1,4.485,1.58,4.755), (4.44,4.485,5.02,4.755)])
A(cmc_s_pmos_b_35717683_x1, licon, 0.775, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(cmc_s_pmos_b_35717683_x1, licon, 4.215, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
R(cmc_s_pmos_b_35717683_x1, licon, [(1.205,4.535,1.375,4.705), (4.645,4.535,4.815,4.705), (1.205,6.635,1.375,6.805), (4.645,6.635,4.815,6.805)])
A(cmc_s_pmos_b_35717683_x1, li1, 0.735, 0.335, 0.25, 3.53, 3, 1, 0.43, 0)
A(cmc_s_pmos_b_35717683_x1, li1, 4.175, 0.335, 0.25, 3.53, 3, 1, 0.43, 0)
R(cmc_s_pmos_b_35717683_x1, li1, [(1.165,4.115,1.415,5.125), (4.605,4.115,4.855,5.125), (1.165,6.215,1.415,7.225), (4.605,6.215,4.855,7.225)])
R(cmc_s_pmos_b_35717683_x1, mcon, [(1.205,0.335,1.375,0.505), (4.645,0.755,4.815,0.925), (0.775,1.175,0.945,1.345), (1.635,1.175,1.805,1.345), (4.215,1.595,4.385,1.765), (5.075,1.595,5.245,1.765), (1.205,4.535,1.375,4.705), (4.645,4.535,4.815,4.705), (1.205,6.635,1.375,6.805), (4.645,6.635,4.815,6.805)])
R(cmc_s_pmos_b_35717683_x1, met1, [(1.12,0.28,2.32,0.56), (3.7,0.7,4.9,0.98), (0.69,1.12,1.89,1.4), (4.13,1.54,5.33,1.82), (1.12,4.48,4.9,4.76), (1.12,6.58,4.9,6.86)])
R(cmc_s_pmos_b_35717683_x1, nsdm, [(0,5.88,6.02,7.56)])
R(cmc_s_pmos_b_35717683_x1, psdm, [(0,0,6.02,5.88)])
R(cmc_s_pmos_b_35717683_x1, L100_5, [(0,0,6.02,7.56)])
R(cmc_s_pmos_b_35717683_x1, lvtn, [(1,2.285,1.58,3.385), (4.44,2.285,5.02,3.385)])

dp_nmos_b_70259934_x2_y1 = lib.new_cell('DP_NMOS_B_70259934_X2_Y1_1792788340')
R(dp_nmos_b_70259934_x2_y1, diff, [(0.735,2.415,4.425,3.255)])
A(dp_nmos_b_70259934_x2_y1, tap, 1.205, 6.16, 0.17, 1.12, 4, 1, 0.86, 0)
A(dp_nmos_b_70259934_x2_y1, poly, 1, 1.26, 0.15, 3.36, 8, 1, 0.43, 0)
A(dp_nmos_b_70259934_x2_y1, poly, 1, 4.485, 0.58, 0.27, 4, 1, 0.86, 0)
A(dp_nmos_b_70259934_x2_y1, licon, 0.775, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(dp_nmos_b_70259934_x2_y1, licon, 1.635, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(dp_nmos_b_70259934_x2_y1, licon, 2.495, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(dp_nmos_b_70259934_x2_y1, licon, 3.355, 2.495, 0.17, 0.17, 3, 2, 0.43, 0.34)
A(dp_nmos_b_70259934_x2_y1, licon, 1.205, 4.535, 0.17, 0.17, 4, 2, 0.86, 2.1)
A(dp_nmos_b_70259934_x2_y1, li1, 0.735, 0.335, 0.25, 3.53, 9, 1, 0.43, 0)
A(dp_nmos_b_70259934_x2_y1, li1, 1.165, 4.115, 0.25, 1.01, 4, 2, 0.86, 2.1)
A(dp_nmos_b_70259934_x2_y1, mcon, 0.775, 1.175, 0.17, 0.17, 5, 1, 0.86, 0)
A(dp_nmos_b_70259934_x2_y1, mcon, 1.205, 6.635, 0.17, 0.17, 4, 1, 0.86, 0)
R(dp_nmos_b_70259934_x2_y1, mcon, [(1.205,0.335,1.375,0.505), (3.785,0.335,3.955,0.505), (2.065,0.755,2.235,0.925), (2.925,0.755,3.095,0.925), (1.205,4.535,1.375,4.705), (3.785,4.535,3.955,4.705), (2.065,4.955,2.235,5.125), (2.925,4.955,3.095,5.125)])
R(dp_nmos_b_70259934_x2_y1, met1, [(1.12,0.28,4.04,0.56), (1.98,0.7,3.18,0.98), (0.69,1.12,4.47,1.4), (1.12,4.48,4.04,4.76), (1.98,4.9,3.18,5.18), (1.12,6.58,4.04,6.86)])
R(dp_nmos_b_70259934_x2_y1, nsdm, [(0,0,5.16,5.88)])
R(dp_nmos_b_70259934_x2_y1, psdm, [(0,5.88,5.16,7.56)])
R(dp_nmos_b_70259934_x2_y1, L100_5, [(0,0,5.16,7.56)])
R(dp_nmos_b_70259934_x2_y1, lvtn, [(0.645,2.285,4.515,3.385)])

telescopic_ota_0 = lib.new_cell('TELESCOPIC_OTA_0')
R(telescopic_ota_0, li1, [(2.025,23.855,2.275,24.025), (2.025,23.855,2.275,24.025), (2.025,23.94,2.275,30.24), (2.025,30.155,2.275,30.325), (2.025,30.155,2.275,30.325)])
R(telescopic_ota_0, mcon, [(2.065,23.855,2.235,24.025), (2.065,23.855,2.235,24.025), (2.065,30.155,2.235,30.325), (2.065,30.155,2.235,30.325)])
R(telescopic_ota_0, met1, [(1.56,6.58,1.88,6.86), (1.56,6.58,1.88,6.86), (1.99,8.26,2.31,8.54), (1.99,8.26,2.31,8.54), (1.99,8.26,2.31,8.54), (1.99,8.26,2.31,8.54), (1.56,13.72,1.88,14), (1.56,13.72,1.88,14), (3.44,14.14,4.3,14.42), (4.14,14.14,4.46,14.42), (4.14,14.14,4.46,14.42), (1.56,14.56,1.88,14.84), (1.56,14.56,1.88,14.84), (1.99,15.82,2.31,16.1), (1.99,15.82,2.31,16.1), (4.14,20.86,4.46,21.14), (4.14,20.86,4.46,21.14), (1.56,21.28,1.88,21.56), (1.56,21.28,1.88,21.56), (4.14,21.7,4.46,21.98), (4.14,21.7,4.46,21.98), (1.56,22.12,1.88,22.4), (1.56,22.12,1.88,22.4), (1.56,22.96,1.88,23.24), (1.56,22.96,1.88,23.24), (4.14,23.38,4.46,23.66), (4.14,23.38,4.46,23.66), (1.72,23.8,2.15,24.08), (1.98,23.8,2.32,24.08), (1.98,23.8,2.32,24.08), (4.14,24.22,4.46,24.5), (4.14,24.22,4.46,24.5), (1.99,29.26,2.31,29.54), (1.99,29.26,2.31,29.54), (1.98,30.1,2.32,30.38), (1.98,30.1,2.32,30.38), (2.15,30.1,2.58,30.38), (2.42,30.1,2.74,30.38), (2.42,30.1,2.74,30.38), (4.14,30.52,4.46,30.8), (4.14,30.52,4.46,30.8), (2.42,30.94,2.74,31.22), (2.42,30.94,2.74,31.22)])
P(telescopic_ota_0, met1, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(telescopic_ota_0, via, [(1.645,6.645,1.795,6.795), (1.645,6.645,1.795,6.795), (2.075,8.325,2.225,8.475), (2.075,8.325,2.225,8.475), (2.075,8.325,2.225,8.475), (2.075,8.325,2.225,8.475), (1.645,13.785,1.795,13.935), (1.645,13.785,1.795,13.935), (4.225,14.205,4.375,14.355), (4.225,14.205,4.375,14.355), (1.645,14.625,1.795,14.775), (1.645,14.625,1.795,14.775), (2.075,15.885,2.225,16.035), (2.075,15.885,2.225,16.035), (4.225,20.925,4.375,21.075), (4.225,20.925,4.375,21.075), (1.645,21.345,1.795,21.495), (1.645,21.345,1.795,21.495), (4.225,21.765,4.375,21.915), (4.225,21.765,4.375,21.915), (1.645,22.185,1.795,22.335), (1.645,22.185,1.795,22.335), (1.645,23.025,1.795,23.175), (1.645,23.025,1.795,23.175), (4.225,23.445,4.375,23.595), (4.225,23.445,4.375,23.595), (4.225,24.285,4.375,24.435), (4.225,24.285,4.375,24.435), (2.075,29.325,2.225,29.475), (2.075,29.325,2.225,29.475), (2.505,30.165,2.655,30.315), (2.505,30.165,2.655,30.315), (4.225,30.585,4.375,30.735), (4.225,30.585,4.375,30.735), (2.505,31.005,2.655,31.155), (2.505,31.005,2.655,31.155)])
R(telescopic_ota_0, met2, [(2.01,6.3,2.29,8.4), (1.58,6.56,1.86,6.88), (1.58,6.56,1.86,6.88), (1.58,6.72,1.86,13.86), (2.01,8.24,2.29,8.56), (2.01,8.24,2.29,8.56), (2.01,8.24,2.29,8.56), (2.01,8.24,2.29,8.56), (2.01,8.4,2.29,15.96), (1.58,13.7,1.86,14.02), (1.58,13.7,1.86,14.02), (4.16,14.12,4.44,14.44), (4.16,14.12,4.44,14.44), (4.16,14.28,4.44,21), (1.58,14.54,1.86,14.86), (1.58,14.54,1.86,14.86), (1.58,14.7,1.86,21.42), (2.01,15.8,2.29,16.12), (2.01,15.8,2.29,16.12), (4.16,20.84,4.44,21.16), (4.16,20.84,4.44,21.16), (1.58,21.26,1.86,21.58), (1.58,21.26,1.86,21.58), (4.16,21.68,4.44,22), (4.16,21.68,4.44,22), (4.16,21.84,4.44,23.52), (1.58,22.1,1.86,22.42), (1.58,22.1,1.86,22.42), (1.58,22.26,1.86,23.1), (1.58,22.94,1.86,23.26), (1.58,22.94,1.86,23.26), (4.16,23.36,4.44,23.68), (4.16,23.36,4.44,23.68), (4.16,24.2,4.44,24.52), (4.16,24.2,4.44,24.52), (4.16,24.36,4.44,30.66), (2.01,29.24,2.29,29.56), (2.01,29.24,2.29,29.56), (2.01,29.4,2.29,31.5), (2.44,30.08,2.72,30.4), (2.44,30.08,2.72,30.4), (2.44,30.24,2.72,31.08), (4.16,30.5,4.44,30.82), (4.16,30.5,4.44,30.82), (2.44,30.92,2.72,31.24), (2.44,30.92,2.72,31.24)])
P(telescopic_ota_0, met2, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(telescopic_ota_0, L104_0, [(-4,-4,10.02,41.8)])
R(telescopic_ota_0, L235_5, [(0,0,6.02,37.8)])
telescopic_ota_0.add(gdstk.Reference(scm_nmos_462578_x1_y1_17, (0,7.56), x_reflection=True))
telescopic_ota_0.add(gdstk.Reference(cmc_pmos_58951767_x1_y1_, (4.73,30.24), rotation=pi, x_reflection=True))
telescopic_ota_0.add(gdstk.Reference(cmc_s_nmos_b_53754070_x1, (0,22.68), x_reflection=True))
telescopic_ota_0.add(gdstk.Reference(cmc_s_pmos_b_35717683_x1, (0,22.68)))
telescopic_ota_0.add(gdstk.Reference(dp_nmos_b_70259934_x2_y1, (0.43,15.12), x_reflection=True))
telescopic_ota_0.add(gdstk.Label('0', (2.15,3.57), layer=69, texttype=5))
telescopic_ota_0.add(gdstk.Label('VBIASP2', (3.01,34.86), layer=68, texttype=5))
telescopic_ota_0.add(gdstk.Label('VDD', (3.01,29.4), layer=68, texttype=5))
telescopic_ota_0.add(gdstk.Label('VOUTN', (1.72,22.26), layer=68, texttype=5))
telescopic_ota_0.add(gdstk.Label('VOUTP', (4.3,21.84), layer=68, texttype=5))
telescopic_ota_0.add(gdstk.Label('VBIASN', (3.01,18.06), layer=68, texttype=5))
telescopic_ota_0.add(gdstk.Label('VBIASP1', (3.01,27.3), layer=68, texttype=5))
telescopic_ota_0.add(gdstk.Label('VINP', (3.01,10.5), layer=68, texttype=5))
telescopic_ota_0.add(gdstk.Label('VINN', (3.01,10.08), layer=68, texttype=5))

lib.write_gds('TELESCOPIC_OTA_0.gds')
