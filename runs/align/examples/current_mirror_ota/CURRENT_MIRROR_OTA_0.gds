# Layout, gdstk code
from math import pi, radians
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
nwell = (64, 20)
diff = (65, 20)
tap = (65, 44)
poly = (66, 20)
licon = (66, 44)
li1 = (67, 20)
mcon = (67, 44)
met1 = (68, 20)
via = (68, 44)
met2 = (69, 20)
via2 = (69, 44)
met3 = (70, 20)
via3 = (70, 44)
met4 = (71, 20)
nsdm = (93, 44)
psdm = (94, 20)
L100_5 = (100, 5)
L104_0 = (104, 0)
L235_5 = (235, 5)

scm_nmos_65859185_x2_y1_ = lib.new_cell('SCM_NMOS_65859185_X2_Y1_1792787857')
R(scm_nmos_65859185_x2_y1_, diff, [(0.735,2.31,7.865,3.36)])
A(scm_nmos_65859185_x2_y1_, tap, 1.635, 6.16, 0.17, 1.12, 4, 1, 1.72, 0)
A(scm_nmos_65859185_x2_y1_, poly, 1, 1.26, 0.15, 3.36, 16, 1, 0.43, 0)
A(scm_nmos_65859185_x2_y1_, poly, 1, 4.485, 1.44, 0.27, 4, 1, 1.72, 0)
A(scm_nmos_65859185_x2_y1_, licon, 0.775, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_65859185_x2_y1_, licon, 2.495, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_65859185_x2_y1_, licon, 4.215, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_65859185_x2_y1_, licon, 5.935, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_65859185_x2_y1_, licon, 1.635, 4.535, 0.17, 0.17, 4, 2, 1.72, 2.1)
A(scm_nmos_65859185_x2_y1_, li1, 0.735, 0.335, 0.25, 3.53, 9, 1, 0.86, 0)
A(scm_nmos_65859185_x2_y1_, li1, 1.595, 4.115, 0.25, 1.01, 4, 2, 1.72, 2.1)
A(scm_nmos_65859185_x2_y1_, mcon, 0.775, 1.175, 0.17, 0.17, 5, 1, 1.72, 0)
A(scm_nmos_65859185_x2_y1_, mcon, 1.635, 4.535, 0.17, 0.17, 4, 2, 1.72, 2.1)
R(scm_nmos_65859185_x2_y1_, mcon, [(1.635,0.335,1.805,0.505), (6.795,0.335,6.965,0.505), (3.355,0.755,3.525,0.925), (5.075,0.755,5.245,0.925)])
R(scm_nmos_65859185_x2_y1_, met1, [(1.55,0.28,7.05,0.56), (3.27,0.7,5.33,0.98), (0.69,1.12,7.91,1.4), (1.55,4.48,7.05,4.76), (1.55,6.58,7.05,6.86)])
R(scm_nmos_65859185_x2_y1_, via, [(3.795,0.345,3.945,0.495), (4.655,1.185,4.805,1.335), (3.795,4.545,3.945,4.695), (4.655,6.645,4.805,6.795)])
R(scm_nmos_65859185_x2_y1_, met2, [(3.73,0.26,4.01,4.78), (4.59,1.1,4.87,6.88)])
R(scm_nmos_65859185_x2_y1_, nsdm, [(0,0,8.6,5.88)])
R(scm_nmos_65859185_x2_y1_, psdm, [(0,5.88,8.6,7.56)])
R(scm_nmos_65859185_x2_y1_, L100_5, [(0,0,8.6,7.56)])

scm_pmos_21041144_x3_y3_ = lib.new_cell('SCM_PMOS_21041144_X3_Y3_1792787859')
R(scm_pmos_21041144_x3_y3_, nwell, [(0,0,12.04,19.32)])
A(scm_pmos_21041144_x3_y3_, diff, 0.735, 2.31, 10.57, 1.05, 1, 3, 0, 5.88)
A(scm_pmos_21041144_x3_y3_, tap, 1.635, 17.92, 0.17, 1.12, 6, 1, 1.72, 0)
A(scm_pmos_21041144_x3_y3_, poly, 1, 1.26, 0.15, 3.36, 24, 3, 0.43, 5.88)
A(scm_pmos_21041144_x3_y3_, poly, 1, 4.485, 1.44, 0.27, 6, 3, 1.72, 5.88)
A(scm_pmos_21041144_x3_y3_, licon, 0.775, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 2.495, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 4.215, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 5.935, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 7.655, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 9.375, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 1.635, 4.535, 0.17, 0.17, 6, 3, 1.72, 5.88)
A(scm_pmos_21041144_x3_y3_, licon, 0.775, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 2.495, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 4.215, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 5.935, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 7.655, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 9.375, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 0.775, 14.15, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 2.495, 14.15, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 4.215, 14.15, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 5.935, 14.15, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 7.655, 14.15, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_pmos_21041144_x3_y3_, licon, 9.375, 14.15, 0.17, 0.17, 3, 3, 0.86, 0.34)
R(scm_pmos_21041144_x3_y3_, licon, [(1.635,18.395,1.805,18.565), (1.635,18.395,1.805,18.565), (1.635,18.395,1.805,18.565), (3.355,18.395,3.525,18.565), (3.355,18.395,3.525,18.565), (3.355,18.395,3.525,18.565), (5.075,18.395,5.245,18.565), (5.075,18.395,5.245,18.565), (5.075,18.395,5.245,18.565), (6.795,18.395,6.965,18.565), (6.795,18.395,6.965,18.565), (6.795,18.395,6.965,18.565), (8.515,18.395,8.685,18.565), (8.515,18.395,8.685,18.565), (8.515,18.395,8.685,18.565), (10.235,18.395,10.405,18.565), (10.235,18.395,10.405,18.565), (10.235,18.395,10.405,18.565)])
A(scm_pmos_21041144_x3_y3_, li1, 0.735, 0.335, 0.25, 3.53, 13, 3, 0.86, 5.88)
A(scm_pmos_21041144_x3_y3_, li1, 1.595, 4.115, 0.25, 1.01, 6, 3, 1.72, 5.88)
A(scm_pmos_21041144_x3_y3_, li1, 1.595, 17.975, 0.25, 1.01, 6, 1, 1.72, 0)
A(scm_pmos_21041144_x3_y3_, mcon, 1.635, 0.335, 0.17, 0.17, 3, 2, 3.44, 6.3)
A(scm_pmos_21041144_x3_y3_, mcon, 3.355, 0.755, 0.17, 0.17, 3, 2, 3.44, 5.46)
A(scm_pmos_21041144_x3_y3_, mcon, 0.775, 1.175, 0.17, 0.17, 7, 3, 1.72, 5.88)
A(scm_pmos_21041144_x3_y3_, mcon, 1.635, 4.535, 0.17, 0.17, 6, 3, 1.72, 5.88)
A(scm_pmos_21041144_x3_y3_, mcon, 1.635, 12.095, 0.17, 0.17, 3, 1, 3.44, 0)
A(scm_pmos_21041144_x3_y3_, mcon, 3.355, 12.515, 0.17, 0.17, 3, 1, 3.44, 0)
A(scm_pmos_21041144_x3_y3_, mcon, 1.635, 18.395, 0.17, 0.17, 6, 1, 1.72, 0)
A(scm_pmos_21041144_x3_y3_, met1, 0.69, 1.12, 10.66, 0.28, 1, 3, 0, 5.88)
A(scm_pmos_21041144_x3_y3_, met1, 1.55, 4.48, 8.94, 0.28, 1, 3, 0, 5.88)
R(scm_pmos_21041144_x3_y3_, met1, [(1.55,0.28,8.77,0.56), (3.27,0.7,10.49,0.98), (3.27,6.16,10.49,6.44), (1.55,6.58,8.77,6.86), (1.55,12.04,8.77,12.32), (3.27,12.46,10.49,12.74), (1.55,18.34,10.49,18.62)])
A(scm_pmos_21041144_x3_y3_, via, 5.945, 0.765, 0.15, 0.15, 1, 3, 0, 5.88)
A(scm_pmos_21041144_x3_y3_, via, 6.375, 1.185, 0.15, 0.15, 1, 3, 0, 5.88)
R(scm_pmos_21041144_x3_y3_, via, [(5.515,0.345,5.665,0.495), (5.515,4.545,5.665,4.695), (5.515,6.225,5.665,6.375), (5.515,10.425,5.665,10.575), (5.515,12.105,5.665,12.255), (5.515,16.305,5.665,16.455), (6.375,18.405,6.525,18.555)])
R(scm_pmos_21041144_x3_y3_, met2, [(5.45,0.26,5.73,16.54), (5.88,0.68,6.16,12.76), (6.31,1.1,6.59,18.64)])
R(scm_pmos_21041144_x3_y3_, nsdm, [(0,17.64,12.04,19.32)])
R(scm_pmos_21041144_x3_y3_, psdm, [(0,0,12.04,17.64)])
R(scm_pmos_21041144_x3_y3_, L100_5, [(0,0,12.04,19.32)])

scm_nmos_b_68452298_x4_y = lib.new_cell('SCM_NMOS_B_68452298_X4_Y2_1792787858')
R(scm_nmos_b_68452298_x4_y, diff, [(0.735,2.31,14.745,3.36), (0.735,8.19,14.745,9.24)])
A(scm_nmos_b_68452298_x4_y, tap, 1.635, 12.04, 0.17, 1.12, 8, 1, 1.72, 0)
A(scm_nmos_b_68452298_x4_y, poly, 1, 1.26, 0.15, 3.36, 32, 2, 0.43, 5.88)
A(scm_nmos_b_68452298_x4_y, poly, 1, 4.485, 1.44, 0.27, 8, 2, 1.72, 5.88)
A(scm_nmos_b_68452298_x4_y, licon, 0.775, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 2.495, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 4.215, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 5.935, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 7.655, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 9.375, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 11.095, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 12.815, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 1.635, 4.535, 0.17, 0.17, 8, 2, 1.72, 5.88)
A(scm_nmos_b_68452298_x4_y, licon, 0.775, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 2.495, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 4.215, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 5.935, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 7.655, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 9.375, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 11.095, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(scm_nmos_b_68452298_x4_y, licon, 12.815, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
R(scm_nmos_b_68452298_x4_y, licon, [(1.635,12.515,1.805,12.685), (1.635,12.515,1.805,12.685), (3.355,12.515,3.525,12.685), (3.355,12.515,3.525,12.685), (5.075,12.515,5.245,12.685), (5.075,12.515,5.245,12.685), (6.795,12.515,6.965,12.685), (6.795,12.515,6.965,12.685), (8.515,12.515,8.685,12.685), (8.515,12.515,8.685,12.685), (10.235,12.515,10.405,12.685), (10.235,12.515,10.405,12.685), (11.955,12.515,12.125,12.685), (11.955,12.515,12.125,12.685), (13.675,12.515,13.845,12.685), (13.675,12.515,13.845,12.685)])
A(scm_nmos_b_68452298_x4_y, li1, 0.735, 0.335, 0.25, 3.53, 17, 2, 0.86, 5.88)
A(scm_nmos_b_68452298_x4_y, li1, 1.595, 4.115, 0.25, 1.01, 8, 2, 1.72, 5.88)
A(scm_nmos_b_68452298_x4_y, li1, 1.595, 12.095, 0.25, 1.01, 8, 1, 1.72, 0)
A(scm_nmos_b_68452298_x4_y, mcon, 0.775, 1.175, 0.17, 0.17, 9, 2, 1.72, 5.88)
A(scm_nmos_b_68452298_x4_y, mcon, 1.635, 4.535, 0.17, 0.17, 8, 2, 1.72, 5.88)
A(scm_nmos_b_68452298_x4_y, mcon, 1.635, 12.515, 0.17, 0.17, 8, 1, 1.72, 0)
R(scm_nmos_b_68452298_x4_y, mcon, [(1.635,0.335,1.805,0.505), (6.795,0.335,6.965,0.505), (8.515,0.335,8.685,0.505), (13.675,0.335,13.845,0.505), (3.355,0.755,3.525,0.925), (5.075,0.755,5.245,0.925), (10.235,0.755,10.405,0.925), (11.955,0.755,12.125,0.925), (3.355,6.215,3.525,6.385), (5.075,6.215,5.245,6.385), (10.235,6.215,10.405,6.385), (11.955,6.215,12.125,6.385), (1.635,6.635,1.805,6.805), (6.795,6.635,6.965,6.805), (8.515,6.635,8.685,6.805), (13.675,6.635,13.845,6.805)])
R(scm_nmos_b_68452298_x4_y, met1, [(1.55,0.28,13.93,0.56), (3.27,0.7,12.21,0.98), (0.69,1.12,14.79,1.4), (1.55,4.48,13.93,4.76), (3.27,6.16,12.21,6.44), (1.55,6.58,13.93,6.86), (0.69,7,14.79,7.28), (1.55,10.36,13.93,10.64), (1.55,12.46,13.93,12.74)])
R(scm_nmos_b_68452298_x4_y, via, [(7.235,0.345,7.385,0.495), (7.665,0.765,7.815,0.915), (8.095,1.185,8.245,1.335), (7.235,4.545,7.385,4.695), (7.235,6.225,7.385,6.375), (7.665,6.645,7.815,6.795), (8.095,7.065,8.245,7.215), (7.235,10.425,7.385,10.575)])
R(scm_nmos_b_68452298_x4_y, met2, [(7.17,0.26,7.45,10.66), (7.6,0.68,7.88,6.88), (8.03,1.1,8.31,7.3)])
R(scm_nmos_b_68452298_x4_y, nsdm, [(0,0,15.48,11.76)])
R(scm_nmos_b_68452298_x4_y, psdm, [(0,11.76,15.48,13.44)])
R(scm_nmos_b_68452298_x4_y, L100_5, [(0,0,15.48,13.44)])

dp_nmos_b_35307796_x2_y2 = lib.new_cell('DP_NMOS_B_35307796_X2_Y2_1792787856')
R(dp_nmos_b_35307796_x2_y2, diff, [(0.735,2.31,7.865,3.36), (0.735,8.19,7.865,9.24)])
A(dp_nmos_b_35307796_x2_y2, tap, 1.635, 12.04, 0.17, 1.12, 4, 1, 1.72, 0)
A(dp_nmos_b_35307796_x2_y2, poly, 1, 1.26, 0.15, 3.36, 16, 2, 0.43, 5.88)
A(dp_nmos_b_35307796_x2_y2, poly, 1, 4.485, 1.44, 0.27, 4, 2, 1.72, 5.88)
A(dp_nmos_b_35307796_x2_y2, licon, 0.775, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(dp_nmos_b_35307796_x2_y2, licon, 2.495, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(dp_nmos_b_35307796_x2_y2, licon, 4.215, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(dp_nmos_b_35307796_x2_y2, licon, 5.935, 2.39, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(dp_nmos_b_35307796_x2_y2, licon, 1.635, 4.535, 0.17, 0.17, 4, 2, 1.72, 5.88)
A(dp_nmos_b_35307796_x2_y2, licon, 0.775, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(dp_nmos_b_35307796_x2_y2, licon, 2.495, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(dp_nmos_b_35307796_x2_y2, licon, 4.215, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
A(dp_nmos_b_35307796_x2_y2, licon, 5.935, 8.27, 0.17, 0.17, 3, 3, 0.86, 0.34)
R(dp_nmos_b_35307796_x2_y2, licon, [(1.635,12.515,1.805,12.685), (1.635,12.515,1.805,12.685), (3.355,12.515,3.525,12.685), (3.355,12.515,3.525,12.685), (5.075,12.515,5.245,12.685), (5.075,12.515,5.245,12.685), (6.795,12.515,6.965,12.685), (6.795,12.515,6.965,12.685)])
A(dp_nmos_b_35307796_x2_y2, li1, 0.735, 0.335, 0.25, 3.53, 9, 2, 0.86, 5.88)
A(dp_nmos_b_35307796_x2_y2, li1, 1.595, 4.115, 0.25, 1.01, 4, 2, 1.72, 5.88)
A(dp_nmos_b_35307796_x2_y2, li1, 1.595, 12.095, 0.25, 1.01, 4, 1, 1.72, 0)
A(dp_nmos_b_35307796_x2_y2, mcon, 0.775, 1.175, 0.17, 0.17, 5, 2, 1.72, 5.88)
A(dp_nmos_b_35307796_x2_y2, mcon, 1.635, 12.515, 0.17, 0.17, 4, 1, 1.72, 0)
R(dp_nmos_b_35307796_x2_y2, mcon, [(1.635,0.335,1.805,0.505), (6.795,0.335,6.965,0.505), (3.355,0.755,3.525,0.925), (5.075,0.755,5.245,0.925), (1.635,4.535,1.805,4.705), (6.795,4.535,6.965,4.705), (3.355,4.955,3.525,5.125), (5.075,4.955,5.245,5.125), (3.355,6.215,3.525,6.385), (5.075,6.215,5.245,6.385), (1.635,6.635,1.805,6.805), (6.795,6.635,6.965,6.805), (3.355,10.415,3.525,10.585), (5.075,10.415,5.245,10.585), (1.635,10.835,1.805,11.005), (6.795,10.835,6.965,11.005)])
R(dp_nmos_b_35307796_x2_y2, met1, [(1.55,0.28,7.05,0.56), (3.27,0.7,5.33,0.98), (0.69,1.12,7.91,1.4), (1.55,4.48,7.05,4.76), (3.27,4.9,5.33,5.18), (3.27,6.16,5.33,6.44), (1.55,6.58,7.05,6.86), (0.69,7,7.91,7.28), (3.27,10.36,5.33,10.64), (1.55,10.78,7.05,11.06), (1.55,12.46,7.05,12.74)])
R(dp_nmos_b_35307796_x2_y2, via, [(3.365,0.345,3.515,0.495), (3.795,0.765,3.945,0.915), (5.085,1.185,5.235,1.335), (4.225,4.545,4.375,4.695), (4.655,4.965,4.805,5.115), (3.365,6.225,3.515,6.375), (3.795,6.645,3.945,6.795), (5.085,7.065,5.235,7.215), (4.225,10.425,4.375,10.575), (4.655,10.845,4.805,10.995)])
R(dp_nmos_b_35307796_x2_y2, met2, [(3.3,0.26,3.58,6.46), (3.73,0.68,4.01,6.88), (5.02,1.1,5.3,7.3), (4.16,4.46,4.44,10.66), (4.59,4.88,4.87,11.08)])
R(dp_nmos_b_35307796_x2_y2, nsdm, [(0,0,8.6,11.76)])
R(dp_nmos_b_35307796_x2_y2, psdm, [(0,11.76,8.6,13.44)])
R(dp_nmos_b_35307796_x2_y2, L100_5, [(0,0,8.6,13.44)])

current_mirror_ota_0 = lib.new_cell('CURRENT_MIRROR_OTA_0')
R(current_mirror_ota_0, li1, [(7.185,11.675,7.435,11.845), (7.185,11.76,7.435,14.28), (7.185,14.195,7.435,14.365), (7.185,14.195,7.435,14.365), (7.185,14.195,7.435,14.365), (7.185,14.195,7.435,14.365)])
R(current_mirror_ota_0, mcon, [(7.225,11.675,7.395,11.845), (7.225,14.195,7.395,14.365), (7.225,14.195,7.395,14.365), (7.225,14.195,7.395,14.365), (7.225,14.195,7.395,14.365)])
R(current_mirror_ota_0, met1, [(13.76,0.7,18.06,0.98), (17.9,0.7,18.22,0.98), (17.9,0.7,18.22,0.98), (17.9,0.7,18.22,0.98), (29.08,0.7,29.4,0.98), (29.08,0.7,29.4,0.98), (7.15,7.84,7.47,8.12), (7.15,7.84,7.47,8.12), (7.31,7.84,30.96,8.12), (30.8,7.84,31.12,8.12), (30.8,7.84,31.12,8.12), (17.9,8.68,18.22,8.96), (17.9,8.68,18.22,8.96), (17.9,8.68,18.22,8.96), (18.06,8.68,24.51,8.96), (24.35,8.68,24.67,8.96), (21.77,9.1,22.09,9.38), (21.77,9.1,22.09,9.38), (21.93,9.1,27.09,9.38), (26.93,9.1,27.25,9.38), (26.93,9.1,27.25,9.38), (32.52,9.1,32.84,9.38), (32.52,9.1,32.84,9.38), (32.68,9.1,41.71,9.38), (41.55,9.1,41.87,9.38), (41.55,9.1,41.87,9.38), (26.93,9.52,27.25,9.8), (26.93,9.52,27.25,9.8), (27.09,9.52,32.25,9.8), (32.09,9.52,32.41,9.8), (32.09,9.52,32.41,9.8), (7.14,11.62,7.48,11.9), (7.15,11.62,7.47,11.9), (7.161,11.62,7.459,11.9), (7.14,14.14,7.48,14.42), (7.14,14.14,7.48,14.42), (7.14,14.14,7.48,14.42), (7.14,14.14,7.48,14.42), (8.01,14.98,8.33,15.26), (8.01,14.98,8.33,15.26), (8.01,14.98,8.33,15.26), (8.01,14.98,8.33,15.26), (8.17,14.98,23.65,15.26), (23.49,14.98,23.81,15.26), (23.49,14.98,23.81,15.26), (23.49,14.98,23.81,15.26), (23.49,14.98,23.81,15.26)])
P(current_mirror_ota_0, met1, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(current_mirror_ota_0, via, [(17.985,0.765,18.135,0.915), (17.985,0.765,18.135,0.915), (17.985,0.765,18.135,0.915), (29.165,0.765,29.315,0.915), (29.165,0.765,29.315,0.915), (7.235,7.905,7.385,8.055), (7.235,7.905,7.385,8.055), (30.885,7.905,31.035,8.055), (30.885,7.905,31.035,8.055), (17.985,8.745,18.135,8.895), (17.985,8.745,18.135,8.895), (17.985,8.745,18.135,8.895), (24.435,8.745,24.585,8.895), (21.855,9.165,22.005,9.315), (21.855,9.165,22.005,9.315), (27.015,9.165,27.165,9.315), (27.015,9.165,27.165,9.315), (32.605,9.165,32.755,9.315), (32.605,9.165,32.755,9.315), (41.635,9.165,41.785,9.315), (41.635,9.165,41.785,9.315), (27.015,9.585,27.165,9.735), (27.015,9.585,27.165,9.735), (32.175,9.585,32.325,9.735), (32.175,9.585,32.325,9.735), (7.235,11.685,7.385,11.835), (8.095,15.045,8.245,15.195), (8.095,15.045,8.245,15.195), (8.095,15.045,8.245,15.195), (8.095,15.045,8.245,15.195), (23.575,15.045,23.725,15.195), (23.575,15.045,23.725,15.195), (23.575,15.045,23.725,15.195), (23.575,15.045,23.725,15.195)])
R(current_mirror_ota_0, met2, [(17.92,0.68,18.2,1), (17.92,0.68,18.2,1), (17.92,0.68,18.2,1), (29.1,0.68,29.38,1), (29.1,0.68,29.38,1), (17.92,0.84,18.2,8.82), (29.1,0.84,29.38,8.82), (8.03,7.375,8.31,7.745), (8.03,7.375,8.31,7.745), (42,7.375,42.28,7.745), (42,7.375,42.28,7.745), (7.17,7.82,7.45,8.14), (7.17,7.82,7.45,8.14), (30.82,7.82,31.1,8.14), (30.82,7.82,31.1,8.14), (7.6,8.635,7.88,9.005), (7.6,8.635,7.88,9.005), (21.36,8.635,21.64,9.005), (21.36,8.635,21.64,9.005), (23.51,8.635,23.79,9.005), (23.51,8.635,23.79,9.005), (23.51,8.635,23.79,9.005), (23.51,8.635,23.79,9.005), (24.37,8.635,24.65,9.005), (29.1,8.635,29.38,9.005), (29.1,8.635,29.38,9.005), (17.92,8.66,18.2,8.98), (17.92,8.66,18.2,8.98), (17.92,8.66,18.2,8.98), (24.37,8.66,24.65,8.98), (24.37,8.699,24.65,8.941), (23.51,8.82,23.79,15.12), (21.79,9.08,22.07,9.4), (21.79,9.08,22.07,9.4), (26.95,9.08,27.23,9.4), (26.95,9.08,27.23,9.4), (32.54,9.08,32.82,9.4), (32.54,9.08,32.82,9.4), (41.57,9.08,41.85,9.4), (41.57,9.08,41.85,9.4), (26.95,9.24,27.23,9.66), (26.95,9.5,27.23,9.82), (26.95,9.5,27.23,9.82), (32.11,9.5,32.39,9.82), (32.11,9.5,32.39,9.82), (7.17,11.6,7.45,11.92), (8.03,14.96,8.31,15.28), (8.03,14.96,8.31,15.28), (8.03,14.96,8.31,15.28), (8.03,14.96,8.31,15.28), (23.51,14.96,23.79,15.28), (23.51,14.96,23.79,15.28), (23.51,14.96,23.79,15.28), (23.51,14.96,23.79,15.28), (20.93,17.455,21.21,17.825), (20.93,17.455,21.21,17.825), (42.43,17.455,42.71,17.825), (42.43,17.455,42.71,17.825), (42.43,17.455,42.71,17.825)])
P(current_mirror_ota_0, met2, [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)],
  [(0,0),(0,0),(0,0),(0,0)])
R(current_mirror_ota_0, via2, [(8.07,7.46,8.27,7.66), (8.07,7.46,8.27,7.66), (42.04,7.46,42.24,7.66), (42.04,7.46,42.24,7.66), (7.64,8.72,7.84,8.92), (7.64,8.72,7.84,8.92), (21.4,8.72,21.6,8.92), (21.4,8.72,21.6,8.92), (23.55,8.72,23.75,8.92), (23.55,8.72,23.75,8.92), (23.55,8.72,23.75,8.92), (23.55,8.72,23.75,8.92), (24.41,8.72,24.61,8.92), (29.14,8.72,29.34,8.92), (29.14,8.72,29.34,8.92), (20.97,17.54,21.17,17.74), (20.97,17.54,21.17,17.74), (42.47,17.54,42.67,17.74), (42.47,17.54,42.67,17.74), (42.47,17.54,42.67,17.74)])
A(current_mirror_ota_0, met3, -0.4, -0.4, 4.24, 0.8, 3, 2, 3.44, 17.64)
A(current_mirror_ota_0, met3, 23.28, -0.4, 1.2, 0.8, 1, 3, 0, 8.82)
A(current_mirror_ota_0, met3, 23.68, -0.4, 4.24, 0.8, 3, 3, 3.44, 8.82)
A(current_mirror_ota_0, met3, 34, -0.4, 1.92, 0.8, 1, 3, 0, 8.82)
A(current_mirror_ota_0, met3, 35.12, -0.4, 3.12, 0.8, 1, 3, 0, 8.82)
A(current_mirror_ota_0, met3, 37.44, -0.4, 4.24, 0.8, 1, 3, 0, 8.82)
A(current_mirror_ota_0, met3, 40.88, -0.4, 4.24, 0.8, 1, 3, 0, 8.82)
A(current_mirror_ota_0, met3, 44.32, -0.4, 3.44, 0.8, 1, 3, 0, 8.82)
A(current_mirror_ota_0, met3, 46.96, -0.4, 1.6, 0.8, 1, 3, 0, 8.82)
R(current_mirror_ota_0, met3, [(9.92,-0.4,12.24,0.4), (11.44,-0.4,14.16,0.4), (11.675,-0.4,12.005,0.4), (13.36,-0.4,17.6,0.4), (16.8,-0.4,21.04,0.4), (20.24,-0.4,24.08,0.4), (35.355,-0.4,35.685,0.4), (8.005,7.16,8.335,7.96), (8.005,7.16,8.335,7.96), (8.17,7.16,42.14,7.96), (41.975,7.16,42.305,7.96), (41.975,7.16,42.305,7.96), (7.575,8.42,7.905,9.22), (7.575,8.42,7.905,9.22), (7.74,8.42,21.5,9.22), (21.335,8.42,21.665,9.22), (21.335,8.42,21.665,9.22), (23.485,8.42,23.815,9.22), (23.485,8.42,23.815,9.22), (23.485,8.42,23.815,9.22), (23.485,8.42,23.815,9.22), (23.515,8.42,23.845,9.22), (24.345,8.42,24.675,9.22), (29.075,8.42,29.405,9.22), (29.075,8.42,29.405,9.22), (47.195,8.42,47.525,9.22), (9.92,17.24,12.24,18.04), (11.44,17.24,14.16,18.04), (11.675,17.24,12.005,18.04), (13.36,17.24,17.6,18.04), (16.8,17.24,21.04,18.04), (20.24,17.24,24.08,18.04), (20.905,17.24,21.235,18.04), (20.905,17.24,21.235,18.04), (35.355,17.24,35.685,18.04), (42.405,17.24,42.735,18.04), (42.405,17.24,42.735,18.04), (42.405,17.24,42.735,18.04)])
R(current_mirror_ota_0, via3, [(11.74,-0.1,11.94,0.1), (35.42,-0.1,35.62,0.1), (23.58,8.72,23.78,8.92), (47.26,8.72,47.46,8.92), (11.74,17.54,11.94,17.74), (35.42,17.54,35.62,17.74)])
A(current_mirror_ota_0, met4, 11.25, -0.59, 1.18, 10, 4, 2, 11.84, 8.82)
R(current_mirror_ota_0, met4, [(11.25,-0.165,12.43,0.165), (34.93,-0.165,36.11,0.165), (23.09,8.655,24.27,8.985), (46.77,8.655,47.95,8.985), (11.25,17.475,12.43,17.805), (34.93,17.475,36.11,17.805)])
R(current_mirror_ota_0, L104_0, [(-4,-4,52.96,25.59)])
R(current_mirror_ota_0, L235_5, [(0,0,48.96,21.59)])
current_mirror_ota_0.add(gdstk.Reference(scm_nmos_65859185_x2_y1_, (3.44,13.44)))
current_mirror_ota_0.add(gdstk.Reference(scm_pmos_21041144_x3_y3_, (36.12,0.42)))
current_mirror_ota_0.add(gdstk.Reference(scm_pmos_21041144_x3_y3_, (27.52,0.42), rotation=pi, x_reflection=True))
current_mirror_ota_0.add(gdstk.Reference(scm_nmos_b_68452298_x4_y, (15.48,13.44), rotation=pi))
current_mirror_ota_0.add(gdstk.Reference(dp_nmos_b_35307796_x2_y2, (36.12,13.44), rotation=pi))
current_mirror_ota_0.add(gdstk.Label('ID', (7.31,15.96), layer=69, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VOUT', (7.74,9.66), layer=69, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VINP', (31.82,5.88), layer=69, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VINN', (31.39,5.46), layer=69, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (15.91,15.12), layer=68, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VSS', (23.68,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VDD', (35.52,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VDD', (35.52,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VDD', (35.52,13.23), layer=71, texttype=5))
current_mirror_ota_0.add(gdstk.Label('VDD', (35.52,13.23), layer=71, texttype=5))

lib.write_gds('CURRENT_MIRROR_OTA_0.gds')
