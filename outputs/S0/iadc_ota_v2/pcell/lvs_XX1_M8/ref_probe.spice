.subckt XX1_M8 A B
.ends
