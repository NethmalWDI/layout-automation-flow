.subckt XM45 A B
.ends
