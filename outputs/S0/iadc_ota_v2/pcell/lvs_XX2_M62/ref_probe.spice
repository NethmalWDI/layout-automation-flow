.subckt XX2_M62 A B
.ends
