.subckt XX2_M41 A B
.ends
