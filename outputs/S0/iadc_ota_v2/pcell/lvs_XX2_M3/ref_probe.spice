.subckt XX2_M3 A B
.ends
