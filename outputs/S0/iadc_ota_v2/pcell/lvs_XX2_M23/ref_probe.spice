.subckt XX2_M23 A B
.ends
