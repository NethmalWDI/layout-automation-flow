.subckt XX2_M24 A B
.ends
