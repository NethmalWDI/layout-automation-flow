.subckt XX2_M61 A B
.ends
