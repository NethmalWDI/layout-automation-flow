.subckt XX1_M36 A B
.ends
