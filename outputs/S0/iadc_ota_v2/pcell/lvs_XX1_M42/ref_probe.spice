.subckt XX1_M42 A B
.ends
