.subckt XX1_M59 A B
.ends
