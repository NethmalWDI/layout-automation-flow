.subckt XX1_M58 A B
.ends
