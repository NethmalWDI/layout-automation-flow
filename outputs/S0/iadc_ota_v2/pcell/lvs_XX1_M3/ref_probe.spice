.subckt XX1_M3 A B
.ends
