.subckt XX2_M38 A B
.ends
