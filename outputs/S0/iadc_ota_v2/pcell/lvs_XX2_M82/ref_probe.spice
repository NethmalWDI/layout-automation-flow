.subckt XX2_M82 A B
.ends
