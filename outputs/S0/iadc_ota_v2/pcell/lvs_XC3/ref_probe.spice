.subckt XC3 A B
.ends
