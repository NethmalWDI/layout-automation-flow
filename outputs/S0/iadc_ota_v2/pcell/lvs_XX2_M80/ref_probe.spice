.subckt XX2_M80 A B
.ends
