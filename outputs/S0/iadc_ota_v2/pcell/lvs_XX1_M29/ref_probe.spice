.subckt XX1_M29 A B
.ends
