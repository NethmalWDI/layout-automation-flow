.subckt XX2_M56 A B
.ends
