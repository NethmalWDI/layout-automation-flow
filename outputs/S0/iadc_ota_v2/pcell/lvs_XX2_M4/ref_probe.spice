.subckt XX2_M4 A B
.ends
