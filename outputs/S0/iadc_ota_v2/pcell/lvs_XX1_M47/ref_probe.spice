.subckt XX1_M47 A B
.ends
