.subckt XX1_M37 A B
.ends
