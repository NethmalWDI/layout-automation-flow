.subckt XX2_M55 A B
.ends
