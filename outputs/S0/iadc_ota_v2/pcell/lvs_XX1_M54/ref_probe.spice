.subckt XX1_M54 A B
.ends
