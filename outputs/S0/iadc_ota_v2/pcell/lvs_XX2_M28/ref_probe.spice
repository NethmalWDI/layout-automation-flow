.subckt XX2_M28 A B
.ends
