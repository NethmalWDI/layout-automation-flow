.subckt XX2_M3A A B
.ends
