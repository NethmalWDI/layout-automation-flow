.subckt XX1_M26 A B
.ends
