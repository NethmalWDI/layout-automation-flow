.subckt XX1_M35 A B
.ends
