.subckt XX2_M12 A B
.ends
