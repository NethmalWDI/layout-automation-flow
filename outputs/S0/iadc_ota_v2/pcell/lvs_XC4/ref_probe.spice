.subckt XC4 A B
.ends
