.subckt XX1_M48 A B
.ends
