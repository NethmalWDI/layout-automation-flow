.subckt XX1_M7 A B
.ends
