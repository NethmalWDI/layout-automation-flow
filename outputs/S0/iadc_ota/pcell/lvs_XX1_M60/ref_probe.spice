.subckt XX1_M60 A B
.ends
