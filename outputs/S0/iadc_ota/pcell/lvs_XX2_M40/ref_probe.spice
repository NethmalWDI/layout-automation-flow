.subckt XX2_M40 A B
.ends
