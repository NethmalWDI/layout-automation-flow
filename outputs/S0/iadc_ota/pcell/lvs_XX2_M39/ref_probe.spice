.subckt XX2_M39 A B
.ends
