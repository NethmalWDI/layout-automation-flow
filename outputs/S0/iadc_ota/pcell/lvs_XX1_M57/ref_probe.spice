.subckt XX1_M57 A B
.ends
