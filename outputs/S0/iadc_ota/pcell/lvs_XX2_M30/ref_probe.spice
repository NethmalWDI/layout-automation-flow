.subckt XX2_M30 A B
.ends
