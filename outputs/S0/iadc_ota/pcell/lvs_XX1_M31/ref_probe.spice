.subckt XX1_M31 A B
.ends
