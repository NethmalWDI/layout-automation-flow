.subckt XX2_M2 A B
.ends
