.subckt XX1_M21 A B
.ends
