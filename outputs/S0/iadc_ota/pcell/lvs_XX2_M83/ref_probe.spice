.subckt XX2_M83 A B
.ends
