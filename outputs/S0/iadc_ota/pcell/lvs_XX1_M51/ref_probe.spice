.subckt XX1_M51 A B
.ends
