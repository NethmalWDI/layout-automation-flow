.subckt XX1_M34 A B
.ends
