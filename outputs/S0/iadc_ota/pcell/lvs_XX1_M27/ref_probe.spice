.subckt XX1_M27 A B
.ends
