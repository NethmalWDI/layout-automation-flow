.subckt XX2_M6 A B
.ends
