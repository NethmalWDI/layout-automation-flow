.subckt XX2_M81 A B
.ends
