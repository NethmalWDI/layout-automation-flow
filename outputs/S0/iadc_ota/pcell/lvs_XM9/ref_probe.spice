.subckt XM9 A B
.ends
