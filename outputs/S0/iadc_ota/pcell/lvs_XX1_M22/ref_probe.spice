.subckt XX1_M22 A B
.ends
