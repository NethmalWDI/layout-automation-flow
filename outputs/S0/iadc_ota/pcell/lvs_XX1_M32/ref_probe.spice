.subckt XX1_M32 A B
.ends
