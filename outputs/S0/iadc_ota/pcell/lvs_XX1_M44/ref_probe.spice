.subckt XX1_M44 A B
.ends
