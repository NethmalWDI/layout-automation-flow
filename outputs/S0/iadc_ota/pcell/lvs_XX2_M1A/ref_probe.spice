.subckt XX2_M1A A B
.ends
