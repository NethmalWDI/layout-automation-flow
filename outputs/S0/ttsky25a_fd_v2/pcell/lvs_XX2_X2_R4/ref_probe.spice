.subckt XX2_X2_R4 A B
.ends
