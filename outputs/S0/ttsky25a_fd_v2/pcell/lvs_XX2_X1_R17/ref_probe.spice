.subckt XX2_X1_R17 A B
.ends
