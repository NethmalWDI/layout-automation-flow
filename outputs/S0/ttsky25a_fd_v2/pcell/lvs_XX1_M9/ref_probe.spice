.subckt XX1_M9 A B
.ends
