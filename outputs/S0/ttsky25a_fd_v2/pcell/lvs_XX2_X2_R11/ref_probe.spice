.subckt XX2_X2_R11 A B
.ends
