.subckt XX2_X2_R17 A B
.ends
