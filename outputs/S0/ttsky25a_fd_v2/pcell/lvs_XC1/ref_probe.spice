.subckt XC1 A B
.ends
