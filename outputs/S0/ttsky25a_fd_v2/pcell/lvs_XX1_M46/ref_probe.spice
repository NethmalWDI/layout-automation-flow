.subckt XX1_M46 A B
.ends
