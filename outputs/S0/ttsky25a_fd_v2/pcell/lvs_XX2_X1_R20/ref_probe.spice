.subckt XX2_X1_R20 A B
.ends
