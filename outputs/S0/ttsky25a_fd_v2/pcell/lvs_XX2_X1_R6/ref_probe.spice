.subckt XX2_X1_R6 A B
.ends
