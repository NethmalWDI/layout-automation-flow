.subckt XX2_M8 A B
.ends
