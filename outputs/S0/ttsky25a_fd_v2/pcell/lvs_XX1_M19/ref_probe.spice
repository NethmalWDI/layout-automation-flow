.subckt XX1_M19 A B
.ends
