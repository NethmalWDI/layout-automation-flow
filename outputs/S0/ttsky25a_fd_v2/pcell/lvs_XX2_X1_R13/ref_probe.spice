.subckt XX2_X1_R13 A B
.ends
