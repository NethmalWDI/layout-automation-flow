.subckt XX2_M7 A B
.ends
