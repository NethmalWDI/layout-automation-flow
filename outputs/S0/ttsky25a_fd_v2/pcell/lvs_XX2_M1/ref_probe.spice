.subckt XX2_M1 A B
.ends
