.subckt XX2_X2_R8 A B
.ends
