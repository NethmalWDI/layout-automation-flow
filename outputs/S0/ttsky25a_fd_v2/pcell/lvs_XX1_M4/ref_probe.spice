.subckt XX1_M4 A B
.ends
