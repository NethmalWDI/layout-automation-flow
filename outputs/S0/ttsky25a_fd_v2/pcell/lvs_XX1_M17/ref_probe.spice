.subckt XX1_M17 A B
.ends
