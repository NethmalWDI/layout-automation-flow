.subckt XX1_M5 A B
.ends
