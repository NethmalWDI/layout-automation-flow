.subckt XX2_M11 A B
.ends
