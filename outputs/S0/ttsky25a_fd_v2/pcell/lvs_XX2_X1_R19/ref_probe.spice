.subckt XX2_X1_R19 A B
.ends
