.subckt XM42 A B
.ends
