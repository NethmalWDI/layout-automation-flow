.subckt XX2_X1_R18 A B
.ends
