.subckt XX1_M6 A B
.ends
