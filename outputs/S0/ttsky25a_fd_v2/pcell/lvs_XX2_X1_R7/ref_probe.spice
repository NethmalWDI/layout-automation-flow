.subckt XX2_X1_R7 A B
.ends
