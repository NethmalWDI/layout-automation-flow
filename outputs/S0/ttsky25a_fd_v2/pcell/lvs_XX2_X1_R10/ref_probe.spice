.subckt XX2_X1_R10 A B
.ends
