.subckt XM34 A B
.ends
