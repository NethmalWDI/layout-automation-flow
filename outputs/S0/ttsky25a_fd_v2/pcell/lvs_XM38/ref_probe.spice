.subckt XM38 A B
.ends
