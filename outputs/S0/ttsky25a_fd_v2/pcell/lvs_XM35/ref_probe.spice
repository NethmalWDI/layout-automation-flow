.subckt XM35 A B
.ends
