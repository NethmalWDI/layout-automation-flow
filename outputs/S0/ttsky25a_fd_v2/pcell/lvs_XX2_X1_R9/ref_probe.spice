.subckt XX2_X1_R9 A B
.ends
