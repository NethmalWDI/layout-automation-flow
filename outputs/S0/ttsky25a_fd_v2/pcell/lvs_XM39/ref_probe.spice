.subckt XM39 A B
.ends
