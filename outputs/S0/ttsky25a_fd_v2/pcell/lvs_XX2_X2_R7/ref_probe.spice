.subckt XX2_X2_R7 A B
.ends
