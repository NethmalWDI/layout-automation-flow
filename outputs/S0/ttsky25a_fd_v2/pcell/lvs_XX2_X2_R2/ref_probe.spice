.subckt XX2_X2_R2 A B
.ends
