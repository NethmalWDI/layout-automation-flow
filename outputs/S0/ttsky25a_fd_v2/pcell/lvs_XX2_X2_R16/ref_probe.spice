.subckt XX2_X2_R16 A B
.ends
