.subckt XM41 A B
.ends
