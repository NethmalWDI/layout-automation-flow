.subckt XX2_X2_R12 A B
.ends
