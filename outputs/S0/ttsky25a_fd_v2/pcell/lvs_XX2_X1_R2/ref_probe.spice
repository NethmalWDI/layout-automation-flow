.subckt XX2_X1_R2 A B
.ends
