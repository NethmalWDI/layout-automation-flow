.subckt XX2_M5 A B
.ends
