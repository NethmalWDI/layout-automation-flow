.subckt XX1_M2 A B
.ends
