.subckt XX2_X2_R13 A B
.ends
