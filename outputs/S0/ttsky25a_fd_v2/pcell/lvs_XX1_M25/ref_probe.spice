.subckt XX1_M25 A B
.ends
