.subckt XM36 A B
.ends
