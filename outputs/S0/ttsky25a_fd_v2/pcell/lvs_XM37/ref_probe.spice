.subckt XM37 A B
.ends
