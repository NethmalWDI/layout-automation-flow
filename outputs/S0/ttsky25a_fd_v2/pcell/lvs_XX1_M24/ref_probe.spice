.subckt XX1_M24 A B
.ends
