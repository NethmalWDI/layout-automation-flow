.subckt XX2_X1_R1 A B
.ends
