.subckt XX2_X2_R14 A B
.ends
