.subckt XX2_X2_R18 A B
.ends
