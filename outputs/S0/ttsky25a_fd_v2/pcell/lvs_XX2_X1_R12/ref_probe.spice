.subckt XX2_X1_R12 A B
.ends
