.subckt XX1_M1 A B
.ends
