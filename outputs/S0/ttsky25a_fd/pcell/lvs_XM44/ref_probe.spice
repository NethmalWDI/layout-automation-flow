.subckt XM44 A B
.ends
