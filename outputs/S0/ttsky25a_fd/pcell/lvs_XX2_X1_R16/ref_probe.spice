.subckt XX2_X1_R16 A B
.ends
