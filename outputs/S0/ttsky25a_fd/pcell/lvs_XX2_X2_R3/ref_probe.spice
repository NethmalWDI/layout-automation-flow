.subckt XX2_X2_R3 A B
.ends
