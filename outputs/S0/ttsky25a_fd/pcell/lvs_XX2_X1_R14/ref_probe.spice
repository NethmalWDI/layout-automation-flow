.subckt XX2_X1_R14 A B
.ends
