.subckt XX2_X2_R6 A B
.ends
