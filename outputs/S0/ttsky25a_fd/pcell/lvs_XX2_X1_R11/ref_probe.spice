.subckt XX2_X1_R11 A B
.ends
