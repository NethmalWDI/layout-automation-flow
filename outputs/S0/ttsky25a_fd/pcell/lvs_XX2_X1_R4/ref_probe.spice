.subckt XX2_X1_R4 A B
.ends
