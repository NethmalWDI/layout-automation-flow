.subckt XX2_X1_R15 A B
.ends
