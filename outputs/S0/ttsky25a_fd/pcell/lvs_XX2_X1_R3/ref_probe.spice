.subckt XX2_X1_R3 A B
.ends
