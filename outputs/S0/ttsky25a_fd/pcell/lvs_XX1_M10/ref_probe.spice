.subckt XX1_M10 A B
.ends
