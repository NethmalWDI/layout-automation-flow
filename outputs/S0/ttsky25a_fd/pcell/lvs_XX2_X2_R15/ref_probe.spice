.subckt XX2_X2_R15 A B
.ends
