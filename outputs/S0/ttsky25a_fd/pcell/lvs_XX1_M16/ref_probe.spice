.subckt XX1_M16 A B
.ends
