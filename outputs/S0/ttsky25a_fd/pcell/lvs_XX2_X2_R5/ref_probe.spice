.subckt XX2_X2_R5 A B
.ends
