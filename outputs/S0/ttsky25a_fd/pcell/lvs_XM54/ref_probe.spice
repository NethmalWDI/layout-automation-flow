.subckt XM54 A B
.ends
