.subckt XM32 A B
.ends
