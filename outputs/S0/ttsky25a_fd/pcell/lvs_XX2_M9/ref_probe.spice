.subckt XX2_M9 A B
.ends
