.subckt XX2_X2_R19 A B
.ends
