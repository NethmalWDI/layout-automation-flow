.subckt XM33 A B
.ends
