.subckt XX2_X2_R1 A B
.ends
