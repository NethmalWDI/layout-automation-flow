.subckt XX1_M18 A B
.ends
