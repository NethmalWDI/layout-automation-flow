.subckt XX1_M23 A B
.ends
