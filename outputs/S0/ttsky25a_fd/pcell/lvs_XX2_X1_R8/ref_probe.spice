.subckt XX2_X1_R8 A B
.ends
