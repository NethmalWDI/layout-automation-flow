.subckt XC2 A B
.ends
