.subckt XX1_M20 A B
.ends
