.subckt XX2_X1_R5 A B
.ends
