.subckt XX1_M15 A B
.ends
