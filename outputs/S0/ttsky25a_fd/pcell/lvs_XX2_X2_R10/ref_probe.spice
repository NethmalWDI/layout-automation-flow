.subckt XX2_X2_R10 A B
.ends
