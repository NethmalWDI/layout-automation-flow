.subckt XX1_M14 A B
.ends
