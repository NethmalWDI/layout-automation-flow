.subckt XX1_M12 A B
.ends
