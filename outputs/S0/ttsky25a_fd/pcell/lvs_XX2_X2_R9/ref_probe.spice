.subckt XX2_X2_R9 A B
.ends
