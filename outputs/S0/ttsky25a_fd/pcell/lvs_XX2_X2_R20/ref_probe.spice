.subckt XX2_X2_R20 A B
.ends
