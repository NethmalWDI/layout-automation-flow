.subckt XM43 A B
.ends
