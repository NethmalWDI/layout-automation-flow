.subckt XX2_M10 A B
.ends
