.subckt XX1_M13 A B
.ends
