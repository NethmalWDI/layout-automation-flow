.subckt Capacitor2 A B
.ends
